# Keil uVision project MSPG3507_FreeRTOS.uvprojx, settings and files
target MSPM0G3507_FreeRTOS (6230000::V6.23::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: empty_LP_MSPM0G3507_nortos_keil +hex
  BeforeMake: cmd.exe /C "$P../syscfg.bat '$P' empty.syscfg"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: __MSPM0G3507__
  c include: ..;..\source\third_party\CMSIS\Core\Include;..\source;..\0_hal;..\1_core;..\2_device;..\3_board;..\4_facade;..\5_libs;..\6_apps;..\Mid;..\Mid\include;..\Mid\portable;..\Mid\source
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507.sct
  link misc: E:\EmbeddedDevelopment\SoftWare\CCS\TI\mspm0_sdk_2_01_00_03\source\ti\driverlib\lib\keil\m0p\mspm0g1x0x_g3x0x\driverlib.a
  group Source
    ../: empty.c empty.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0g350x_uvision.s
  group Driverlib
    ../source/ti/driverlib/: dl_adc12.c dl_adc12.h dl_aes.c dl_aes.h dl_aesadv.c dl_aesadv.h dl_common.c dl_common.h dl_comp.h dl_crc.c dl_crc.h dl_crcp.c dl_crcp.h dl_dac12.c dl_dac12.h dl_dma.c dl_dma.h dl_flashctl.c dl_flashctl.h dl_gpamp.h dl_gpio.h dl_i2c.c dl_i2c.h dl_iwdt.h dl_keystorectl.c dl_keystorectl.h dl_lcd.c dl_lcd.h dl_lfss.c dl_lfss.h dl_mathacl.c dl_mathacl.h dl_mcan.c dl_mcan.h dl_opa.c dl_opa.h dl_rtc.h dl_rtc_a.h dl_rtc_common.c dl_rtc_common.h dl_scratchpad.h dl_spi.c dl_spi.h dl_tamperio.h dl_timer.c dl_timer.h dl_timera.h dl_timerg.h dl_trng.c dl_trng.h dl_uart.c dl_uart.h dl_uart_extend.h dl_uart_main.h dl_vref.c dl_vref.h dl_wwdt.h driverlib.h
  group FreeRTOS/include
    ../Mid/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group FreeRTOS/portable
    ../Mid/portable/: heap_4.c port.c
  group FreeRTOS/source
    ../Mid/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS
    ../Mid/: FreeRTOS_demo.c FreeRTOS_demo.h FreeRTOSConfig.h my_freetros_lib.c my_freetros_lib.h
  group 2_device
    ../2_device/: OLED_driver.c buzzer_driver.c encoder_driver.c icm42688_driver.c key_driver.c led_driver.c motor_driver.c stepper_driver.c xunji_driver.c mpu6050_driver.c mt6701_driver.c
  group 3_board
    ../3_board/: buzzer_board.c encoder_board.c key_board.c led_board.c oled_board.c xunji_board.c motor_board.c icm42688_board.c mpu6050_board.c mt6701_board.c stepper_board.c uart_board.c uart_board.h
  group 4_facade
    ../4_facade/: buzzer_facade.c encoder_facade.c key_facade.c led_facade.c motor_facade.c uart_facade.h
  group 5_libs
    ../5_libs/: my_system_lib.c my_system_lib.h OLED_Data.c OLED_Data.h OLED_menu.c OLED_menu.h IMU.c IMU.h my_math.c my_math.h
  group 0_hal
    ../0_hal/: hal_iic.c hal_iic.h hal_gpio.c hal_gpio.h hal_gpio_int.c hal_gpio_int.h hal_uart.c hal_uart.h hal_timer.c
  group 6_apps
    ../6_apps/: car_app.c car_app.h xunji_app.c xunji_app.h usart_app.c usart_app.h yuntai_app.c yuntai_app.h
