# Keil uVision project empty.uvprojx, settings and files
target empty (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: empty +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../layer;../layer/platform;../layer/platform/inferface/uart;../layer/platform/inferface/i2c;../layer/platform/inferface/pin;../layer/platform/inferface/pwm;../layer/platform/inferface/encoder_counter;../layer/platform/inferface/timebase;../layer/platform/mcu/stm32f4;../layer/platform/mcu/stm32f4/core;../layer/platform/mcu/stm32f4/uart;../layer/platform/mcu/stm32f4/i2c;../layer/platform/mcu/stm32f4/pin;../layer/platform/mcu/stm32f4/pwm;../layer/platform/mcu/stm32f4/encoder_counter;../layer/device;../layer/device/key;../layer/device/led;../layer/device/encoder;../layer/device/motor;../layer/driver;../layer/driver/key;../layer/driver/led;../layer/driver/encoder;../layer/driver/motor;../layer/component;../layer/component/key;../layer/component/motor_axis;../layer/component/tracking;../layer/component/weixin_protocol;../layer/library;../layer/library/ahrs;../layer/library/filter;../layer/library/math;../layer/library/control;../layer/application/core;../layer/board/stm32f407;../layer/board/stm32f407/i2c;../layer/board/stm32f407/imu;../layer/board/stm32f407/key;../layer/board/stm32f407/led;../layer/board/stm32f407/oled;../layer/board/stm32f407/uart;../layer/board/stm32f407/drive;../layer/board/stm32f407/tracking;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../layer/platform/RTOS;../layer/platform/RTOS/monitor;../layer/platform/RTOS/include;../layer/platform/RTOS/portable
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: freertos.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/User/Platform/Inferface
    ../layer/platform/inferface/pin/: pin.c
    ../layer/platform/inferface/pwm/: pwm.c
    ../layer/platform/inferface/encoder_counter/: encoder_counter.c
    ../layer/platform/inferface/timebase/: timebase.c
    ../layer/platform/inferface/uart/: stdio_uart.c uart.c uart_blocking.c uart_interrupt.c
    ../layer/platform/inferface/i2c/: i2c.c i2c_blocking.c i2c_interrupt.c
  group Application/User/Device
    ../layer/device/led/: led.c
    ../layer/device/key/: key.c
    ../layer/device/imu/: imu.c
    ../layer/device/display/: display.c
    ../layer/device/encoder/: encoder.c
    ../layer/device/motor/: motor.c
  group Application/User/Driver
    ../layer/driver/led/: led_gpio.c led_pwm.c
    ../layer/driver/key/: key_gpio.c
    ../layer/driver/icm42688/: icm42688.c
    ../layer/driver/ssd1306/: ssd1306.c
    ../layer/driver/encoder/: quadrature_encoder.c
    ../layer/driver/motor/: at8236_motor.c
    ../layer/driver/motor/emm_v5/: emm_v5.c
  group Application/User/Board
    ../layer/board/stm32f407/led/: board_led.c
    ../layer/board/stm32f407/key/: board_key.c
    ../layer/board/stm32f407/uart/: board_uart.c
    ../layer/board/stm32f407/i2c/: board_i2c.c
    ../layer/board/stm32f407/oled/: board_oled.c
    ../layer/board/stm32f407/drive/: board_drive.c
    ../layer/board/stm32f407/emm_v5/: board_emm_v5.c
    ../layer/board/stm32f407/tracking/: board_tracking.c
  group Application/User/Component
    ../layer/component/tracking/: tracking_inputs.c
    ../layer/component/key/: key_event.c
    ../layer/component/attitude/: attitude.c
    ../layer/component/motor_axis/: motor_axis.c
    ../layer/component/weixin_protocol/: weixin_protocol.c
  group Application/User/Library
    ../layer/library/ahrs/: mahony.c
    ../layer/library/filter/: low_pass_filter.c
    ../layer/library/math/: math_utils.c
    ../layer/library/control/: pid.c
    ../layer/library/graphics/: mono_canvas.c mono_shape.c mono_text.c mono_text_ascii.c mono_text_format.c mono_text_multibyte.c
    ../layer/library/graphics/font/: mono_font_ascii.c
  group Application/User/App/Core
    ../layer/application/core/: main.c app_rtos.c app_led.c app_key.c app_oled.c app_motor.c app_encoder.c app_emm_v5.c app_tracking.c app_serial_monitor.c app_system_stats.c
  group Application/User/Platform/MCU/STM32F4
    ../layer/platform/mcu/stm32f4/core/: stm32f4.c
    ../layer/platform/mcu/stm32f4/pin/: stm32f4_pin.c
    ../layer/platform/mcu/stm32f4/pwm/: stm32f4_pwm.c
    ../layer/platform/mcu/stm32f4/encoder_counter/: stm32f4_encoder_counter.c
    ../layer/platform/mcu/stm32f4/i2c/: stm32f4_i2c.c stm32f4_i2c_sw.c
    ../layer/platform/mcu/stm32f4/uart/: stm32f4_uart.c
  group Application/User/Platform/RTOS
    ../layer/platform/RTOS/monitor/: my_freetros_lib.c
    ../layer/platform/RTOS/portable/: heap_4.c port.c
    ../layer/platform/RTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
software components: CMSIS:CORE 4.3.0
